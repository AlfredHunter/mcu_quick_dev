# Keil uVision project first_try.uvprojx, settings and files
target stm32f1xx_RC (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: first_try
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: RVDS_ARMCM3_LM3S102
  c include: ..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F10xFWLib\inc;..\..\..\..\kernel\RTOS\FreeRTOS\include;..\..\..\..\platforms\MCUs\STM32F1xx;..\..\..\..\boards\noah_sc_v0.1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Applications/first_try
    ../../../../applications/first_try/: main.c
  group Boards/Sensors
    ../../../../boards/noah_sc_v0.1/: ledTest.c
  group kernel/RTOS/FreeRTOS
    ../../../../kernel/RTOS/FreeRTOS/: tasks.c list.c queue.c
    ../../../../kernel/RTOS/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../../../../kernel/RTOS/FreeRTOS/portable/MemMang/: heap_2.c
  group platform/MCUs/STM32F1xx/peripherals/libraries
    ../../../../platforms/MCUs/STM32F1xx/peripherals/libraries/STM32F10xFWLib/src/: stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c
  group platform/MCUs/STM32F1xx/RVMDK
    ../../../../platforms/MCUs/STM32F1xx/RVMDK/: startup_stm32f1xx_RVMDK.s cortexm3_macro_rvds.s
